# Keil uVision project Cheddar.uvproj, settings and files
target Target 1 (MCS-51)
  device: DP8051 Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000)
  output: Cheddar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Assembly
    ./src/: STARTUP.A51
  group Source
    ./src/: main.c UsbApi.c global.c isr.c UsbLibPro.c UsbDescriptor.c I2C.c CIS.c timer.c
  group Include
    ./src/: platform.h PL2551.h global.h Usb.h UsbStandard.h UsbDescriptor.h I2C.h CIS.h timer.h
target Banner (MCS-51)
  device: DP8051 Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000)
  output: Cheddar +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: OV9155
target PL2551EVB64 (MCS-51)
  device: DP8051 Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000)
  output: Cheddar +hex
  c flags: Optimize=8 SizeSpeed=1
